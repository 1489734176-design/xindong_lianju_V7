# Keil uVision project BLDC-6Step.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32G0001A1TC MindMotion
  pack: MindMotion.MM32G0001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLDC-6Step +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Device\CMSIS\Core\Include;..\Device\MM32G0001\Include;..\Device\MM32G0001\HAL_Lib\inc;..\USER;..\DRIVE\inc;..\MC_CORE;..\SYS;..\MOTOR_CONTROL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group StartUP
    ../Device/MM32G0001/Source/KEIL_StartAsm/: startup_mm32g0001_keil.s
    ../Device/MM32G0001/Source/: system_mm32g0001.c
  group HAL_Lib
    ../Device/MM32G0001/HAL_Lib/src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group USER
    ../USER/: main.c mm32g0001_it.c platform.c board.c parameter.h user_control.c led.c flash_data_save.c user_control.h
  group DRIVE
    ../DRIVE/src/: drv_pwm.c drv_adc.c
  group SYSTEM
    ../SYS/: systick.c
  group MC_CORE
    ../MC_CORE/: 001mc_core_lib_V5.lib
  group MOTOR_CONTROL
    ../MOTOR_CONTROL/: motor_control.c motor_control.h motor_config.h
